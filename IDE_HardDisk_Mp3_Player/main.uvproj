# Keil uVision project main.uvproj, settings and files
target IDE (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MP3_firmware +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: main.c ATAPI6.C serial.c vs1003.c
  group znFAT
    ./znFAT/: deviceio.c znFAT.c
